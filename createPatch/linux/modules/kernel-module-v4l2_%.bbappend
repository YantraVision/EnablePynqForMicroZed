FILESEXTRAPATHS_prepend := "${THISDIR}/kernel-module-v4l2:"

SRC_URI_append +="file://disable_Print_dmesg.patch \
"
